<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ddc_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>DDC Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50e6</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>50e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ddc_ogain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>DDC Out Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>duc_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>DUC Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50e6</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>50e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>duc_ogain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>DUC Out Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>2.395e9</value></param>
<param><key>label</key><value>RX Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2.3e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>2.5e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>2.395e9</value></param>
<param><key>label</key><value>TX Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2.3e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>2.5e9</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>32000</value></param>
<param><key>freq</key><value>500e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>avs4000_avs4000rx</key>
<param><key>id</key><value>avs4000_avs4000rx_0</value></param>
<param><key>ddcFreq</key><value>ddc_freq</value></param>
<param><key>ddcOutGain</key><value>ddc_ogain</value></param>
<param><key>dn</key><value>deviceNum</value></param>
<param><key>ppsSel</key><value>"internal"</value></param>
<param><key>rxFreq</key><value>rx_freq</value></param>
<param><key>rxRFBW</key><value>0</value></param>
<param><key>refMaster</key><value>True</value></param>
<param><key>refMode</key><value>"Internal"</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>startMode</key><value>"Immediate"</value></param>
<param><key>sysSync</key><value>False</value></param>
<param><key>tbSrc</key><value>"host"</value></param>
</block>
<block>
<key>avs4000_avs4000stat</key>
<param><key>id</key><value>avs4000_avs4000stat_0</value></param>
<param><key>dn</key><value>deviceNum</value></param>
</block>
<block>
<key>avs4000_avs4000tx</key>
<param><key>id</key><value>avs4000_avs4000tx_0</value></param>
<param><key>ducFreq</key><value>duc_freq</value></param>
<param><key>ducOutGain</key><value>duc_ogain</value></param>
<param><key>dn</key><value>deviceNum</value></param>
<param><key>txOutRxEn</key><value>False</value></param>
<param><key>ppsSel</key><value>"internal"</value></param>
<param><key>txRFBW</key><value>0</value></param>
<param><key>refMaster</key><value>False</value></param>
<param><key>refMode</key><value>"Internal"</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>startMode</key><value>"Immediate"</value></param>
<param><key>sysSync</key><value>False</value></param>
<param><key>ampEnable</key><value>False</value></param>
<param><key>txFreq</key><value>tx_freq</value></param>
<param><key>tbSrc</key><value>"host"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deviceNum</value></param>
<param><key>label</key><value>deviceNum</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>100</value></param>
<param><key>ymin</key><value>-20</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>10000</value></param>
<param><key>ymin</key><value>-10000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>avs4000_avs4000tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avs4000_avs4000rx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avs4000_avs4000rx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
