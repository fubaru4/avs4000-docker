<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>880e6</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>800e6</value></param>
<param><key>step</key><value>10e3</value></param>
<param><key>stop</key><value>1200e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>50e6</value></param>
</block>
<block>
<key>avs4000_avs4000rx</key>
<param><key>id</key><value>avs4000_avs4000rx_1</value></param>
<param><key>ddcFreq</key><value>0</value></param>
<param><key>ddcOutGain</key><value>0</value></param>
<param><key>dn</key><value>1</value></param>
<param><key>ppsSel</key><value>"internal"</value></param>
<param><key>rxFreq</key><value>rx_freq</value></param>
<param><key>rxRFBW</key><value>0</value></param>
<param><key>refMaster</key><value>True</value></param>
<param><key>refMode</key><value>"Internal"</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>startMode</key><value>"Immediate"</value></param>
<param><key>sysSync</key><value>False</value></param>
<param><key>tbSrc</key><value>"host"</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>5000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>avs4000_avs4000rx_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avs4000_avs4000rx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
